# Keil uVision project STM32Cube.uvprojx, settings and files
target STM32Cube (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: STM32Cube +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: STM32F405xx,USE_FULL_LL_DRIVER,USE_HAL_DRIVER,ARM_MATH_CM4,__TARGET_FPU_VFP
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Components;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Components/sensors;../Components/actuators;../Components/link;../Components/filter
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f405xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c i2c.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_ll_adc.c stm32f4xx_ll_gpio.c stm32f4xx_ll_dma.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_ll_rcc.c stm32f4xx_ll_utils.c stm32f4xx_ll_exti.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_ll_tim.c stm32f4xx_ll_usart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Components
    ../Components/actuators/: dshot.c mixer.c
    ../Components/link/: crsf.c si24r1.c param.c
    ../Components/sensors/: icm42688p.c qmc5883l.c spl06.c stm32_i2c_driver.c
    ../Components/: ahrs_dcm.c simple_math.c so3_controller.c system.c
    ../Components/filter/: butter.c
software components: CMSIS:CORE 5.4.0, CMSIS:DSP 1.8.0
